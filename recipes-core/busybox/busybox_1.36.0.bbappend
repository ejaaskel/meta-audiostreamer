FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-start-stop-daemon-add-chdir-option.patch"

